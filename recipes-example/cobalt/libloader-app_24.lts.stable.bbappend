require cobalt_dac.inc
SRC_URI += "file://0002-remove-rfc-api-24.patch;patchdir=../larboard"
DEPENDS:remove = " virtual/vendor-secapi2-adapter virtual/vendor-gst-drm-plugins "
