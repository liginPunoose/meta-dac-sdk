#stub class for the build to succeed
